;GCD 
	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	LDR R0, =N1
	LDR R1, =N2
	LDR R0, [R0]
	LDR R1, [R1]
UP
	CMP R0, R1
	BEQ  EXIT
	BL SKIP
	SUB R0, R1
SKIP
	SUB R1, R0
	B UP
EXIT
	LDR R3, =RES
	STR R0, [R3]
STOP B STOP

	AREA MYDATA, DATA, READWRITE
N1 DCD 3
N2 DCD 18
RES DCD 0
	END
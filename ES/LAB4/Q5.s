;32 bit - unpacked 
	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R8,=0 ;BIT SHIFTING COUNTER
	LDR R5,=0X00000215; NUMBER FOR CONVERSION
	MOV R1,#0X0A ; FOR REPEATED SUBTRACTION
	MOV R0,R5 ; TO KEEP THE INITIAL NUMBER UNAFFECTED
	LDR R7,=0; FINAL ANSWER
	MOV R2,#08; COUNTER FOR NUMBER OF DIGITS.
UP CMP R0,#0
	BEQ EXIT
	BL DIV
	LSL R5,R5,R8
	ADD R7,R7,R5
	ADD R8,#04
	MOV R0,R4
	SUB R2,#01
	TEQ R2,#0
	BNE UP
	B BYE
DIV MOV R3,#0;QUOTIENT
UP1 CMP R0,R1
	BLO EXIT
	SUB R0,R1
	ADD R3,#01
	B UP1
EXIT MOV R4,R3; R4 HAS QUOTIENT
	MOV R5,R0; R5 HAS REMAINDER
	BX LR
BYE 
STOP B STOP
	END
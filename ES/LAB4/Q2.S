;CONVERT 8-DIGIT HEX IN UNPACKED ASCII FORMINTO PACKED FORM
	AREA RESET,DATA,READONLY
	EXPORT __Vectors
	
__Vectors
    DCD 0x10001000
	DCD Reset_Handler
	
	AREA MYCODE,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler

Reset_Handler
	LDR R0, =NUM
	MOV R5,#08; FIRST COUNTER, TO CONVERT ASCII INTO THE EQUIVALENT DIGIT.

UP1 LDRB R1,[R0]
	CMP R1,#0X40
	BLO DOWN
	SUB R1,#07
DOWN SUB R1,#0X30
    STRB R1,[R0]
	ADD R0,#01
	SUB R5,#01
	TEQ R5,#0
	BNE UP1

; EACH OF THE NUMBERS IN THE MEMORY HAS BEEN INDIVIDUALLY CONVERTED TO THE RESPECTIVE DIGIT.	
    LDR R9,=0;RESULT STORED HERE
	MOV R5,#8
	LDR R4,=04; COUNTER FOR THE LEFT SHIFTING

UP2 LDRB R1,[R0],#-1
    LSL R9,R4
	ADD R9,R9,R1
	;ADD R4,#04
	SUB R5,#01
	TEQ R5,#0
	BNE UP2

STOP B STOP
	AREA MYDATA,DATA,READWRITE
NUM DCD 0,0
	END
	
    
	AREA RESET, DATA, READONLY 
	EXPORT __Vectors

__Vectors 
	DCD 0X10001000
	DCD Reset_Handler
	
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	MOV R6, #04
	LDR R0, =num1
	LDR R1, =num2
	LDR R2, =res
	LDR R7, =0X20000000
	MSR XPSR, R7
BACK 
	LDR R3, [R0], #04
	LDR R4, [R1], #04
	SBCS R5, R3, R4 
	STR R5, [R2], #04
	SUB R6, #01
	TEQ R6, #00
	BNE BACK
	
	SBC R6, #00
	STR R6, [R2]
STOP B STOP
num1 DCD 0XFFFFFFFF, 0XFFFFFFFF, 0XFFFFFFFF, 0XFFFFFFFF
num2 DCD 0X11111111, 0X11111111, 0XFFFFFFFF, 0X11111112

	AREA mydata, DATA, READWRITE
res DCD 0, 0, 0, 0
	END
	
	
